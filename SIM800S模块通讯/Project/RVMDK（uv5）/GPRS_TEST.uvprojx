# Keil uVision project GPRS_TEST.uvprojx, settings and files
target tcp_test (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPRS_TEST +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\Libraries;..\..\User;..\..\Hardware\DATA_UNIT;..\..\Hardware\GPIO;..\..\Hardware\GPRS_WIS800C;..\..\Hardware\PC_USART1;..\..\Hardware\SYSTICK;..\..\Hardware\TIM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c
  group HARDWARE
    ../../Hardware/SYSTICK/: systick.c systick.h
    ../../Hardware/TIM/: tim.c tim.h
    ../../Hardware/PC_USART1/: pc_usart1.c pc_usart1.h
    ../../Hardware/GPRS_WIS800C/: gprs_uart2.c gprs_uart2.h gprs_at.c gprs_at.h
    ../../Hardware/DATA_UNIT/: data_unit.c data_unit.h
    ../../Hardware/GPIO/: gpio.c gpio.h
